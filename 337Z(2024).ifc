Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2024-01-29T00:39:17
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Jan 29 00:39:17 2024 * Host: DESKTOP-13TP49N * Database: C:\Users\andre\AppData\Local\Temp\8f60cd24-d351-4d47-92a9-e92f049f2c17\b51bfbce-4df9-4c7e-8ce4-fffe955e8f03\ifc * Database version: 5507 * Database creation date: Mon Jan 29 00:39:17 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Jan 29 00:39:17 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Jan 29 00:39:17 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Other - Category: Project Information

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcFlowController: 337Z Oras, 337Z(2024):337Z Oras:154971
In: Level 1
Type - PredefinedType: FAUCET
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - InletConnectionSize: 10 mm; NominalDepth: 66.9785 mm; NominalHeight: 318.711 mm; NominalWidth: 56.721 mm
Type - Electrical - Battery: CR 2450 3 V; Bluetooth: 5.x (D060577); Operating Voltage: 3 V; Protection Class: IP 55
Type - General - Author: BIMStone; BIMObjectName: 337Z(2024); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Shower mixers; NBSReference: 45-35-70/335; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_78; Uniclass2015Description: Shower manual water supply sets; Uniclass2015Reference: Pr_40_20_87_78; Version: 1; VersionDate: 17/01/2024
Type - Green Building Properties - EAN Number: 6414150105173; EMC Directive: Radio Equipment Directive 2014/53/EU , Low Voltage Directive 2014/35/EU , EMC Directive 2014/30/EU , RoHS Directive 2011/65/EU; EN Standard: ETSI EN 301 489-1 V1.9.2 , ETSI EN 300 328 v2.2.2 , EN 61000-6-1:2007 , EN 61000-6-3:2007+A1:2011+AC:2012 , EN 60335-1:2012+A11+A13+A1+A14+A2+A15:2021, Part 19.11.4; URL Declaration of Asbestos: http://static.oras.com/doc/asbestos; URL Declaration of Conformity: http://static.oras.com/DoC/337Z; URL Declaration Of Performance (DOP): http://static.oras.com/doc/DoP; URL Declaration of SCIP: http://static.oras.com/doc/SCIP; URL EcoLabel Declaration: http://static.oras.com/doc/EcoLabel; URL EU Packaging Declaration: http://static.oras.com/doc/packaging; URL REACH: http://static.oras.com/doc/reach; URL WEEE: http://static.oras.com/WEEE/337Z
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/337Z; Catalog Drawing URL: http://static.oras.com/catdrw/337Z; Dimension Drawing URL: http://static.oras.com/dimdrw/337Z; FDV Document URL: http://www.oras.com/datasheet/337Z/en/fdv; Group: Sales item; Manufacturer: Oras; Market: International;Finland; Mobile Product Information URL: http://mpi.oras.com/337Z; Model: 337Z Oras; Name_en: 337Z Oras; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 337Z; Product Family: null Battery-operated;Bluetooth®; Product Image URL: http://static.oras.com/image/337Z; Product URL: http://static.oras.com/337Z; Short Marketing: Remote bidetta set designed for Oras Touchless faucets and remote bidetta units. including Bidetta handshower, shower hose and remote handshower wall holder; Technical DataSheet URL: http://www.oras.com/datasheet/337Z/en; Type Name: 337Z Oras; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Hand Shower: Remote-operated Smart Bidetta; Max Flow Period: 2 min (1 - 1800 s); Shower Parts: Shower hose (1750 mm); Surface treatment: Chrome
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 337Z(2024); Features: HandShowerSets; Finish: Polished; Grade: n/a; ModelNumber: n/a; ModelReference: 337Z; Name: 337Z Oras; ReplacementCost: n/a; Shape: Sculptured; Size: 170x85x200 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - DefaultElevation: 900 mm; Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset from Host: 0 mm
Dimensions - Area: 0.0432571 m2; Volume: 0.00121267 m3
Identity Data - Mark: 63
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 337Z(2024): 337Z Oras; Family and Type: 337Z(2024): 337Z Oras; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 337Z(2024): 337Z Oras; Type Id: 337Z(2024): 337Z Oras; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
